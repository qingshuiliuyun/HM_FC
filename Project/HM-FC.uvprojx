# Keil uVision project HM-FC.uvprojx, settings and files
target FLASH (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HM-FC
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --c99
  c include: ..\Project;..\Application\inc;..\Hardware\inc;..\Software\inc;..\Model\FixWing;..\Model\MultiRotor;..\Library\inc;..\Library\STM32_USB-FS-Device_Driver\inc;..\FreeRTOS\inc;..\FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./: startup_stm32f10x_md.s
  group application
    ../Application/src/: main.c stm32f10x_it.c
  group software
    ../Software/src/: sbus.c Parameter.c Protocol.c imu.c mymath.c AirPlane.c
    ../Hardware/src/: tim.c
  group hardware
    ../Hardware/src/: rcc.c sys.c led.c usart.c 24C02.c i2c.c Senser.c adc.c MPXV7002.c ak8975.c HMC5883L.c mpu6050.c ms5611.c ublox.c
  group Model/FixWing
    ../Model/FixWing/: FixedWing.c
  group library
    ../Library/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c misc.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_i2c.c stm32f10x_dma.c
  group FreeOS
    ../FreeRTOS/: croutine.c list.c port.c queue.c tasks.c timers.c heap_2.c
target RAM (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: HM-FC
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\APP\inc;..\APP\startup;..\Hardware\inc;..\Library\inc;..\Project
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.0.2
